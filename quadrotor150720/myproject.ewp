# IAR project myproject.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512Zxxx10 Freescale MK60DN512Zxxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: IAR; TWR_K60N512
  ICCARM.CCIncludePath2: src\Sources\H; src\Sources\H\Component_H; src\Sources\H\Frame_H
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: myproject.srec
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Ram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: src\Project_Settings\Link\Pflash.icf
  group Project_Settings/link
    src/Project_Settings/Link/: Pflash.icf Ram.icf
  group Project_Settings/Startup_Code
    src/Project_Settings/Startup_Code/: crt0.s start.c
  group Sources/C
    src/Sources/C/: isr.c main.c
  group Sources/C/Component_C
    src/Sources/C/Component_C/: Balance_Kalman.c control.c filters.c ftm.c function.c get_data.c HAL_GPIO.c hw_gpio.c hw_i2c.c light.c MahonyAHRS.c OpticaSensor.c pit.c ppl.c queue.c uart.c wdog.c
  group Sources/C/Frame_C
    src/Sources/C/Frame_C/: common.c sysinit.c vectors.c
  group Sources/H
    src/Sources/H/: includes.h
  group Sources/H/Component_H
    src/Sources/H/Component_H/: Balance_Kalman.h control.h filters.h ftm.h function.h get_data.h HAL_GPIO.h hw_gpio.h hw_i2c.h isr.h light.h MahonyAHRS.h OpticalSensor.h pit.h ppl.h queue.h uart.h wdog.h
  group Sources/H/Frame_H
    src/Sources/H/Frame_H/: common.h MK60N512VMD100.h sysinit.h vectors.h
